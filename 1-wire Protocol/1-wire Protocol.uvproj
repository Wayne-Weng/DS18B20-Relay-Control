# Keil uVision project 1-wire Protocol.uvproj, settings and files
target MPC82G516 (MCS-51)
  device: MPC82G516 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x3FF) CLOCK(24000000)
  output: 1-wire Protocol
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Main;.\Source;..\1-wire Protocol
  group Main
    ./Main/: main.c
    ./: DS18B20.c
  group Source
    ./Source/: delaytime.c IO.c UART.c seven_seg.c
