# Keil uVision project Relay Control.uvproj, settings and files
target MPC82G516 (MCS-51)
  device: MPC82G516 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x3FF) CLOCK(24000000)
  output: Relay Control
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Source;..\Relay Control
  group Main
    ./: main.c
  group Source
    ./Source/: delaytime.c UART.c IO.c
